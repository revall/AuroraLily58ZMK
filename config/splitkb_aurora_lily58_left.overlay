#include "splitkb_aurora_lily58.dtsi"

/ {
    /* THIS only makes keymap binding happy, nothing happens on peripheral side */
	glidepoint: virtual_input {
		compatible = "zmk,virtual-input";
	};
};